# Keil uVision project RobotArm.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RobotArm
  AfterMake: fromelf --bin -o build\RobotArm_LPC1768.bin build\RobotArm.axf
  c flags: Optim=1
  c define: TARGET_ARCH_PRO,  TARGET_M3,  TARGET_CORTEX_M,  TARGET_NXP,  TARGET_LPC176X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1430663472.35,  __MBED__=1,  TARGET_LPC1768,  TARGET_FF_ARDUINO,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  Receiver;  FuRoC_FOC_F28027;  mbed;  mbed/TARGET_ARCH_PRO;  mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD;  mbed/TARGET_ARCH_PRO/TARGET_NXP;  mbed/TARGET_ARCH_PRO/TARGET_NXP/TARGET_LPC176X;  mbed/TARGET_ARCH_PRO/TARGET_NXP/TARGET_LPC176X/TARGET_ARCH_PRO
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/system_LPC17xx.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/startup_LPC17xx.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp
    Receiver/: Receive.cpp
    FuRoC_FOC_F28027/: FuRoC_FOC_F28027.cpp
